# Keil uVision project ble_app_lbs_EMC.uvprojx, settings and files
target nRF51422_xxAC (ARM-ADS)
  device: nRF51422_xxAC Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.7.1.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x8000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ble_app_lbs_EMC +hex
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c define: BLE_STACK_SUPPORT_REQD S110 BOARD_PCA10028 SOFTDEVICE_PRESENT NRF51
  c misc: --c99
  library: MicroLIB
  memory RVCT4: ROM 0x18000 size 0x28000
  memory RVCT9: RAM 0x20002000 size 0x6000
  group app
    ./app/: ble_lbs.c main.c
software components: CMSIS:CORE 4.1.0, Board Support:bsp 8.0.0, Device:Startup 7.1.0, nRF_BLE:BLE_Modules:ble_advdata 2.0.0, nRF_BLE:BLE_Modules:ble_common 2.0.0, nRF_BLE:BLE_Modules:ble_conn_params 2.0.0, nRF_BLE:BLE_Modules:ble_debug_assert_handler 2.0.0, nRF_BLE:BLE_Modules:ble_error_log 2.0.0, nRF_BLE:BLE_Modules:ble_service_common 2.0.0, nRF_Drivers:ble_flash 2.0.0, nRF_Drivers:nrf_delay 2.0.0, nRF_Drivers:nrf_error 2.0.0, nRF_Drivers:nrf_gpio 2.0.0, nRF_Drivers:pstorage 2.0.0, nRF_Libraries:app_button 2.0.0, nRF_Libraries:app_error 2.0.0, nRF_Libraries:app_gpiote 2.0.0, nRF_Libraries:app_scheduler 2.0.0, nRF_Libraries:app_timer 2.0.0, nRF_Libraries:app_timer_with_app_scheduler 2.0.0, nRF_Libraries:app_util 2.0.0, nRF_Libraries:nordic_common 2.0.0, nRF_Libraries:nrf_assert 2.0.0, nRF_SoftDevice:Internal:sd_common 1.1.2, nRF_SoftDevice:Internal:softdevice_present 1.1.2, nRF_SoftDevice:s110 8.0.0
